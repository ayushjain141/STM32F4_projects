# Keil uVision project uart_printf_test.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_printf_test_stm32f4 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_STM32F4_DISCOVERY
  c include: ..\..\libs;..\..\libs\rcc_stm32f407_lib;..\..\libs\bsp;..\..\libs\delay_stm32f407_lib;..\..\libs\gpio_stm32f407_lib;..\..\libs\timer_stm32f407_lib;..\..\libs\usart_stm32f407_lib;..\..\libs\utils_stm32f407_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
    ../../libs/bsp/: bsp_aj_stm32f4.c bsp_aj_stm32f4.h
    ../../libs/delay_stm32f407_lib/: delay_aj_stm32f4.c delay_aj_stm32f4.h
    ../../libs/rcc_stm32f407_lib/: rcc_aj_stm32f4.c rcc_aj_stm32f4.h
    ../../libs/timer_stm32f407_lib/: timer_aj_stm32f4.c timer_aj_stm32f4.h
    ../../libs/usart_stm32f407_lib/: usart_aj_stm32f4.c usart_aj_stm32f4.h
    ../../libs/utils_stm32f407_lib/: utils_aj_stm32f4.c utils_aj_stm32f4.h
software components: CMSIS:CORE 5.0.0, Device:Startup 2.6.3
